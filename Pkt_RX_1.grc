options:
  parameters:
    author: Barry Duggan
    description: packet receive (for GNURadio 3.8)
    generate_options: qt_gui
    id: pkt_rcv_gr38
    output_language: python
    title: pkt_rcv_gr38
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: cor
  id: variable
  parameters:
    value: '1001'
  states: {}
- name: digitallmsequalizer
  id: variable_adaptive_algorithm
  parameters:
    cons: bpsk
    step_size: '0.0001'
    type: lms
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: order
  id: variable
  parameters:
    value: '2'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '53'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3000000.178814'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Nathan\Downloads\Bpsk_Rx_output.txt.txt
    type: byte
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: console_0
  id: console
  parameters: {}
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: order
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    adapt_after_training: 'False'
    alg: digitallmsequalizer
    num_taps: '15'
    sps: '4'
    training_sequence: '[1.0,-1.0,1.0,-1.0,1.0,-1.0,1.0,-1.0]'
    training_start_tag: '"Training_begin"'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: ((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    comment: |-
      The LMS DD equalizer has been
      replaced by a Linear Equalizer
      and an Adaptive Algorithm (CMA) for
      version 3.9
    note: LMS equalizer replaced
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    max: '100'
    name: '"Received Numbers"'
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 915e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx2
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}

connections:
- [blocks_repack_bits_bb_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_repack_bits_bb_1, '0', qtgui_number_sink_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_1, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_file_sink_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_crc_append_0, out, blocks_message_debug_1, print]
- [digital_crc_append_0, out, console_0, in]
- [digital_crc_append_0, out, radar_print_results_0, Msg in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [mmse_resampler_xx_0, '0', blocks_throttle2_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc_append_0, in]
- [rational_resampler_xxx_0, '0', blocks_throttle2_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rtlsdr_source_0, '0', mmse_resampler_xx_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_1, '0', digital_diff_decoder_bb_0, '0']
- [virtual_source_2, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
